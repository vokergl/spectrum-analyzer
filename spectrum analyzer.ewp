# IAR project spectrum analyzer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429xx; USE_STM32F429_DISCO; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: C:\Drivers\CMSIS\Device\ST\STM32F4xx\Include; C:\Drivers\STM32F4xx_HAL_Driver\Inc; C:\Drivers\BSP\STM32F429I-Discovery; C:\Users\RVZ8X9Q4\Documents\spectrum analyzer; C:\Users\RVZ8X9Q4\Documents\spectrum analyzer\lcd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: spectrum analyzer.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: FFT.h main.c main.h startup_stm32f429xx.s stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc.h stm32f4xx_hal_conf.h stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
    lcd/: ili9341.c stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
  group lcd
    lcd/: lcd_init.h stm32f429i_discovery.h stm32f429i_discovery_lcd.h stm32f429i_discovery_sdram.h stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_ll_fmc.c
    ./: stm32f429i_discovery_ts.c stm32f4xx_hal_i2c.c stmpe811.c stmpe811.h
